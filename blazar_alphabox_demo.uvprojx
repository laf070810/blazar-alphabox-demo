# Keil uVision project blazar_alphabox_demo.uvprojx, settings and files
target blazar_alphabox_demo Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: blazar_alphabox_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MKL25Z128VLK4, FSL_RTOS_FREE_RTOS, FRDM_KL25Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: blazar;board;source;CMSIS;doc;drivers;freertos;startup;utilities;shell;ugfx;ugfx\drivers\gdisp\ILI9341;ugfx\drivers\ginput\toggle\Pal
  asm define: DEBUG
  asm include: board;source;CMSIS;doc;drivers;freertos;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
  group blazar
    ./blazar/: blazar_7seg.c blazar_7seg.h blazar_accelerometer.c blazar_accelerometer.h blazar_adc.c blazar_adc.h blazar_buzzer.c blazar_buzzer.h blazar_buzzer_data.h blazar_lcd.c blazar_lcd.h blazar_lcd_font.h blazar_lcd_pic.h blazar_led.c blazar_led.h blazar_led_data.h blazar_switch.c blazar_switch.h blazar_rtc.c blazar_rtc.h blazar_flash.h blazar_flash.c
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKL25Z4.h MKL25Z4_features.h system_MKL25Z4.c system_MKL25Z4.h
  group doc/freertos/portable
    doc/freertos/portable/: readme.txt
  group doc/freertos/source
    doc/freertos/source/: readme.txt
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpsci.c fsl_lpsci.h fsl_lpsci_freertos.c fsl_lpsci_freertos.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_freertos.c fsl_uart_freertos.h
    ./drivers/: fsl_tpm.c fsl_tpm.h fsl_adc16.c fsl_adc16.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_dma.c fsl_dma.h fsl_dmamux.c fsl_dmamux.h fsl_rtc.c fsl_rtc.h fsl_pit.c fsl_pit.h
  group freertos
    freertos/: ChangeLogKSDK.txt croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOS_for_Kinetis_SDK_v2.0.txt freertos_tasks_c_additions.h fsl_tickless_generic.h fsl_tickless_lptmr.c fsl_tickless_systick.c heap_4.c list.c list.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group freertos/License
    freertos/License/: license.txt
  group freertos/Source/portable/Keil
    freertos/Source/portable/Keil/: See-also-the-RVDS-directory.txt
  group source
    source/: FreeRTOSConfig.h
    ./source/: main.c gfxconf.h
  group startup
    startup/: startup_MKL25Z4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
    ./utilities/: fsl_shell.c fsl_shell.h
  group shell
    ./shell/: blazar_shell.c blazar_shell.h cmd_adc.c cmd_buzzer.c cmd_hello.c cmd_led.c cmd_switch.c cmd_seg.c cmd_accel.c cmd_homework.c cmd_reset.c
  group ugfx
    ./ugfx/src/: gfx_mk.c
    ./ugfx/drivers/gdisp/ILI9341/: board_ILI9341.h gdisp_lld_ILI9341.c
target blazar_alphabox_demo Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: blazar_alphabox_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, FSL_RTOS_FREE_RTOS, FRDM_KL25Z, FREEDOM
  c misc: as above
  c include: board;source;CMSIS;doc;drivers;freertos;startup;utilities
  asm include: board;source;CMSIS;doc;drivers;freertos;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL25Z128xxx4_flash.scf
  link misc: --remove
